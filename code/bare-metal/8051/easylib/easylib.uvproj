# Keil uVision project easylib.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: easylib +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: EASYLIB_INTERRUPT_SUPPORT,EASYLIB_EXTERNAL_INTERRUPT_SUPPORT,EASYLIB_TIMER_SUPPORT,EASYLIB_POWERDOWN_SUPPORT
  group Source Group 1
    ./Src/: easylib.c main.c
