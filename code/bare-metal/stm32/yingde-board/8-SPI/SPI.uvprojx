# Keil uVision project SPI.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC5)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SPI +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,__CC_ARM
  c include: .\CMSIS;.\FWLIB\inc;.\USER;.\ULIB;.\HW
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group FWLIB
    ./FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STARTUP
    ./CMSIS/startup/arm/: startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_md.s
  group ULIB
    ./ULIB/: ulib_if.h ulib_gpio.h ulib_gpio.c ulib_def.h ulib_assert.h ulib_exti.c ulib_exti.h ulib_uart.c ulib_uart.h ulib_i2c.c ulib_i2c.h ulib_timer.c ulib_timer.h ulib_spi.c ulib_spi.h ulib_adc_dac.c ulib_adc_dac.h ulib_assert.c ulib_dma.c ulib_dma.h ulib_plat_stm32f103c8t6.c
  group HW
    ./HW/: bsp_spi_flash.c bsp_spi_flash.h
